Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-29T16:34:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 29 16:34:12 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\1b08f9e3-5df9-4b62-8c0c-541ee92cb5fe\802cb191-be60-4874-887c-bfe22d46d87b\ifc * Database version: 5507 * Database creation date: Wed Mar 29 16:34:11 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 29 16:34:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 29 16:34:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11845640_USA_M2241SC_OBSW:24224120_USA_11845640_M2241SC_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 24224120_USA_11845640_M2241SC_OBSW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 24224120_USA_11845640_M2241SC_OBSW
Type - Pset_ProvisionForVoid - Depth: 401 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 452 mm

# IfcDistributionPort, Port_353152
Description: Flow; FlowDirection: SOURCEANDSINK
